# Repository aramcon-badge/keyboard-addon

## KiCad design q10keyboard-addon.kicad_pcb

Parts:
C1, C3, C5: 4.7uF; C_0603_1608Metric; LCSC Part C53987
C2, C4, C6, C7, C8: 100nF; C_0603_1608Metric; LCSC Part C14663
D1: LED; LED_0603_1608Metric; LCSC Part C2286
J1: Conn_02x04_Top_Bottom; SOIC_clipProgSmall
J2: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
J3: Conn_01x08_Female; PinSocket_1x06_P2.54mm_Vertical
J4: Conn_01x08_Female; PinSocket_1x08_P2.54mm_Vertical
JP1: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
R1, R5: 10K; R_0603_1608Metric; LCSC Part C25804
R2, R4: 10K; R_0603_1608Metric
R3: 1K; R_0603_1608Metric; LCSC Part C21190
U1: BBQ10KBD; BM14B(0.8)-24DS-0.4V(53)-longpads
U2: STM32F030C8Tx; LQFP-48_7x7mm_P0.5mm; LCSC Part C23922
U3: M24C02-WMN; SOIC-8_3.9x4.9mm_P1.27mm; LCSC Part C7562
X1: Badgelife_sao_connector_v169bis; Badgelife-SAOv169-SAO-2x3

Connections:
/BOOT0: J1.6, R4.1, U2.44 (BOOT0)
/COL1: J3.2, U1.7 (COL1), U2.28 (PB15)
/COL2: J3.3, U1.9 (COL2), U2.27 (PB14)
/COL3: J3.4, U1.10 (COL3), U2.26 (PB13)
/COL4: J3.5, U1.17 (COL4), U2.25 (PB12)
/COL5: J3.6, U1.19 (COL5), U2.22 (PB11)
/LED: D1.1 (K), U2.43 (PB7)
/LEDA_1_2: J2.2, U1.26 (LEDA_1_2), U2.33 (PA12)
/LEDA_3_4: J2.4, U1.24 (LEDA_3_4), U2.31 (PA10)
/LEDK_1_4: J2.3, U1.25 (LEDK_1_4), U2.32 (PA11)
/LEDK_2_3: J2.5, U1.23 (LEDK_2_3), U2.30 (PA9)
/MIC: J4.8, U1.3 (MIC), X1.5 (GPIO1)
/NRST: C7.2, J1.8, U2.7 (NRST)
/ROW1: J4.1, U1.6 (ROW1), U2.16 (PA6)
/ROW2: J4.2, U1.8 (ROW2), U2.15 (PA5)
/ROW3: J4.3, U1.18 (ROW3), U2.14 (PA4)
/ROW4: J4.4, U1.20 (ROW4), U2.13 (PA3)
/ROW5: J4.5, U1.21 (ROW5), U2.12 (PA2)
/ROW6: J4.6, U1.22 (ROW6), U2.11 (PA1)
/ROW7: J4.7, U1.27 (ROW7), U2.10 (PA0)
/SCL: R1.1, U2.45 (PB8), U3.6 (SCL), X1.4 (SCL)
/SDA: R2.1, U2.46 (PB9), U3.5 (SDA), X1.3 (SDA)
/SWCLK: J1.7, U2.37 (PA14)
/SWDIO: J1.5, U2.34 (PA13)
/TX: U2.42 (PB6), X1.6 (GPIO2)
GND: C3.2, C4.2, C5.1, C6.2, C7.1, C8.2, J1.4, J2.6, JP1.1 (A), R4.2, U1.1 (GND), U1.5 (GND), U1.11 (GND), U1.12 (GND), U1.13 (GND), U1.14 (GND), U1.15 (GND), U1.16 (GND), U1.28 (GND), U2.23 (VSS), U2.47 (VSS), U3.4 (VSS), X1.2 (GND)
GNDA: C1.1, C2.2, J3.1, JP1.2 (B), U1.4 (AGND), U2.8 (VSSA)
unnamed: D1.2 (A), R3.1
unnamed: R5.1, U3.7 (~WC)
VCC: C1.2, C2.1, C3.1, C4.1, C5.2, C6.1, C8.1, J1.1, J2.1, R1.2, R2.2, R3.2, R5.2, U1.2 (MIC_VDD), U2.1 (VDD), U2.9 (VDDA), U2.24 (VDD), U2.48 (VDD), U3.8 (VCC), X1.1 (VCC)

Board: 2 copper layers, 65.0 x 63.5 mm, 25 parts (19 on the bottom side), 30 nets.

Other parts of the board:
KBD1: Val**; drawing
svg2mod: G***; aramcon-logo

## Code that names these connections

File firmware/src/main.cpp:

/**
  BB Keyboard Badge Add-on Firmware

  Copyright (C) 2021 Uri Shaked
*/

#include <Arduino.h>
#include <Wire.h>
#include <RingBuf.h>

#define I2C_ADDR 0x42

#define CMD_LEDA12 bit(0)
#define CMD_LEDA34 bit(1)
#define CMD_LEDK14 bit(2)
#define CMD_LEDK23 bit(3)

#define CMD_INT_ENABLE bit(6)
#define CMD_RESET bit(7) /* Resets the keyboard buffer */

#define RESP_FLAG_KEYDOWN bit(6)
#define RESP_FLAG_KEYUP bit(7)
#define RESP_RESET 0xfe     /* Keyboard buffer was reset */
#define RESP_BUF_EMPTY 0xff /* Input buffer empty */

#define KBD_ROWS 7
#define KBD_COLS 5

#define KBD_BUFFER_SIZE 256

const uint8_t rowPins[KBD_ROWS] = {PA6, PA5, PA4, PA3, PA2, PA1, PA0};
const uint8_t colPins[KBD_COLS] = {PB15, PB14, PB13, PB12, PB11};
const uint8_t anodes[2] = {PA10, PA12};
const uint8_t cathodes[2] = {PA9, PA11};
const uint8_t ledPin = PB7;
const uint8_t intPin = PB6;

bool initialized = false;
bool interruptEnabled = false;
RingBuf<byte, KBD_BUFFER_SIZE> kbdBuffer;

/* Slow down clock to 8MHz. This saves a few milliamps! */
extern "C" void SystemClock_Config()
{
  RCC_OscInitTypeDef RCC_OscInitStruct;
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    _Error_Handler(__FILE__, __LINE__);
  }

  RCC_ClkInitTypeDef RCC_ClkInitStruct;
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK | RCC_CLOCKTYPE_SYSCLK | RCC_CLOCKTYPE_PCLK1;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_1) != HAL_OK)
  {
    _Error_Handler(__FILE__, __LINE__);
  }
}

void i2cStarted()
{
  if (!initialized)
  {
    digitalWrite(ledPin, HIGH);
    pinMode(ledPin, INPUT);
  }
  initialized = true;
}

void updateInterrupt()
{
  if (interruptEnabled)
  {
    pinMode(intPin, OUTPUT);
    digitalWrite(intPin, kbdBuffer.isEmpty() ? HIGH : LOW);
  }
  else
  {
    pinMode(intPin, INPUT);
  }
}

void i2cReceive(int count)
{
  i2cStarted();
  while (Wire.available())
  {
    uint8_t cmd = Wire.read();
    if (cmd & CMD_RESET)
    {
      kbdBuffer.clear();
      kbdBuffer.push(RESP_RESET);
    }
    interruptEnabled = cmd & CMD_INT_ENABLE;
    digitalWrite(cathodes[0], cmd & CMD_LEDK23);
    digitalWrite(cathodes[1], cmd & CMD_LEDK14);
    digitalWrite(anodes[0], cmd & CMD_LEDA34);
    digitalWrite(anodes[1], cmd & CMD_LEDA12);
    updateInterrupt();
  }
}

void i2cRequest()
{
  i2cStarted();
  uint8_t item = RESP_BUF_EMPTY; // fallback value
  kbdBuffer.pop(item);
  updateInterrupt();
  Wire.write(item);
}

void setup()
{
  pinMode(ledPin, OUTPUT);
  pinMode(anodes[0], OUTPUT);
  pinMode(anodes[1], OUTPUT);
  pinMode(cathodes[0], OUTPUT);
  pinMode(cathodes[1], OUTPUT);
  for (int i = 0; i < KBD_ROWS; i++)
  {
    pinMode(rowPins[i], INPUT_PULLUP);
  }
  for (int i = 0; i < KBD_COLS; i++)
  {
    pinMode(colPins[i], INPUT);
  }

  // I2C Setup
  Wire.setSCL(PB8);
  Wire.setSDA(PB9);
  Wire.begin(I2C_ADDR);
  Wire.onReceive(i2cReceive);
  Wire.onRequest(i2cRequest);
}

void blinkKeyboard()
{
  digitalWrite(anodes[0], millis() % 1000 >= 500);
  digitalWrite(anodes[1], !digitalRead(anodes[0]));

  // Breathe LED
  int time = millis() % 5000;
  if (time >= 4096)
  {
    digitalWrite(ledPin, HIGH); // LED Off
  }
  else
  {
    uint8_t ledLevel = (time % 2048) / 8;
    analogWrite(ledPin, (time >= 2048) ? ledLevel : 255 - ledLevel);
  }
}

uint8_t keys[KBD_COLS] = {0};

void scanKeyboard()
{
  for (int col = 0; col < KBD_COLS; col++)
  {
    uint8_t colValue = 0;
    pinMode(colPins[col], OUTPUT);
    for (int row = 0; row < KBD_ROWS; row++)
    {
      colValue |= digitalRead(rowPins[row]) ? 0 : bit(row);
    }
    pinMode(colPins[col], INPUT);
    uint8_t changedRows = keys[col] ^ colValue;
    keys[col] = colValue;
    if (changedRows)
    {
      for (int row = 0; row < KBD_ROWS; row++)
      {
        if (changedRows & bit(row))
        {
          bool keyDown = colValue & bit(row);
          uint8_t flag = keyDown ? RESP_FLAG_KEYDOWN : RESP_FLAG_KEYUP;
          kbdBuffer.push((col + 1) | (row + 1) << 3 | flag);
          updateInterrupt();
        }
      }
    }
  }
}

void loop()
{
  if (initialized)
  {
    scanKeyboard();
  }
  else
  {
    blinkKeyboard();
  }
}

## Commit log

2020-01-24 Initial commit
    Simple breakout board for Q10 keyboard
2020-01-24 fix(pcb): keyboard connector orientation
    1. The keyboard connector was in a wrong orientation,
    and had to be rotated 180°.
    2. Move breakout connectors away from keyboard cable
    3. Reduce number of breakout GND pins from 3 to 1
    4. Add ground zone below the keyboard connector to make soldering easier
2020-01-25 feat: elongate keyboard connector pads
2020-01-25 feat: wire the CPU
    also add reset capacitor, boot0 resistor, and round some corners
2020-01-25 feat: prepare for SMT assembly
2020-01-25 fix: keyboard dimensions
    enlarge keyboard by ~1.6%, after measuring with calipers
2020-01-26 feat: add 2kbit EEPROM device
    The EEPROM device will be used to store the add-on id:
    https://github.com/urish/badge-addon-id
2020-01-26 fix: missing power connection for STM32 VDDA pin
2020-02-21 fix: SAO Connector text orientation
2020-03-11 feat: add 3 fiducials
    also move conference logo to solder mask layer
2021-07-01 refactor: move PCB files into subdir
2021-07-01 feat: add firmware

Notices in the files:
q10keyboard-addon.kicad_pcb:
© 2020 Uri Shaked
